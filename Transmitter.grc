options:
  parameters:
    generate_options: qt_gui
    id: Transmitter
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.43e9
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '18'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/engelmf/IT465_Lab2/message.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '18'
    type: byte
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: packet_len
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e6
    fc: 2.43e9
    fftsize: '2048'
    grid: 'True'
    name: Spectrum
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 1e6
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: ''
    gain0: '20'
    samp_rate: 1e6
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
