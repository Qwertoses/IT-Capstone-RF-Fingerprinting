options:
  parameters:
    generate_options: qt_gui
    id: usrp_rx
    output_language: python
    title: usrp_rx IT 465
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: ''
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: ''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: ''
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: rx_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    name: Received Spectrum
    type: complex
    update_time: '0.20'
    ymax: '-20'
    ymin: '-160'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: ''
    gain0: rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [digital_ofdm_rx_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
